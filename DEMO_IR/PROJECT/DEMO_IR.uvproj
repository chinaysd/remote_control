# Keil uVision project DEMO_IR.uvproj, settings and files
target DEMO_IR (MCS-51)
  device: SC92F7003 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: DEMO_IR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USER\Inc
  group APP
    ../USER/Src/: main.c SC92F7003_IT.c
  group SOURCE
    ../USER/Src/: system_init.c timer0.c ir1838.c gpio.c display.c tm1638.c
  group STARTUP
    ./: STARTUP.A51
